Audio Amplifier
.LIB EVAL.LIB
Xa 3 2 7 4 6 UA741
Xb 3 12 7 4 16 UA741
Vin 1 0 SIN(0 100M 50)
R1 1 0 1MEG
C2 1 5 47N
R2 5 2 5.6K
R4 3 0 1MEG
C1 3 0 1U
R10 ;POT
C3 ;POT
R5 6 12 1K
C4 16 7 1U
R12 ;POT
